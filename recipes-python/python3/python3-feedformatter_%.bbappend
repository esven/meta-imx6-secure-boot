BBCLASSEXTEND = "native"

RDEPENDS_${PN}_remove_class-native = "python3-xml-native"
RDEPENDS_${PN}_remove_class-native = "python3-datetime-native"