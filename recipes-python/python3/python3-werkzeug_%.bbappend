BBCLASSEXTEND = "native"

RDEPENDS_${PN}_remove_class-native = "python3-datetime-native"
RDEPENDS_${PN}_remove_class-native = "python3-difflib-native"
RDEPENDS_${PN}_remove_class-native = "python3-unixadmin-native"
RDEPENDS_${PN}_remove_class-native = "python3-html-native"