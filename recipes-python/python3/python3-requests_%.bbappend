BBCLASSEXTEND = "native"

RDEPENDS_${PN}_remove_class-native = "${PYTHON_PN}-email"
RDEPENDS_${PN}_remove_class-native = "${PYTHON_PN}-json"
RDEPENDS_${PN}_remove_class-native = "${PYTHON_PN}-netserver"
