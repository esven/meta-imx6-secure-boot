BBCLASSEXTEND = "native"

RDEPENDS_${PN}_remove_class-native = "${PYTHON_PN}-re"
